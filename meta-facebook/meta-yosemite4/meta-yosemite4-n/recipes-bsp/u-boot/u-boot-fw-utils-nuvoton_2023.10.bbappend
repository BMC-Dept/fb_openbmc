FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-nuvoton:"
SRC_URI:append = " file://0004-Update-ENV_ADDR-and-uimage_flash_addr.patch"
