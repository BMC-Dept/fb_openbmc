FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-yosemite4-fix-threshold-event.patch"
