FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Fix-the-log-file-did-not-rotate-after-the-system-pow.patch \
"
